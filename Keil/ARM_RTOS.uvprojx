# Keil uVision project ARM_RTOS.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\App;..\Kernel;..\Drivers;..\Device
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group App
    ../App/: main.c tasks.c
  group Kernel
    ../Kernel/: Mutex.c os_core.c os_error.c os_malloc.c Semaphore.c os_asm.s
  group Drivers
    ../Drivers/: PLL.c SysTick.c uart.c dwt.c
software components: CMSIS:CORE 6.2.0, Device:Startup 3.2.3
